# Keil uVision project os.uvproj, settings and files
target os (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: os
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group src
    ./src/: main.c uart_polling.c rtx.c printf.c
    ./src/mem/: mem.c
  group sys
    ./sys/: system_LPC17xx.c
  group startup
    ./startup/: startup_LPC17xx.s
